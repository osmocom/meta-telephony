
require ${PN}.inc

PR = "${INC_PR}.1"

