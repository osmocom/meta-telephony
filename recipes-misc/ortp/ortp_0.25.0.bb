require ortp.inc
PR = "${INC_PR}.1"

SRC_URI[md5sum] = "f44b4ab2a8de32c19abfa584c4426f76"
SRC_URI[sha256sum] = "0deb826b79b1fd329f7638821d5439dc343bc55bb122daa6c90d19116cfe8d9a"
