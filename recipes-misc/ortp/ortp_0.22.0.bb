require ortp.inc
DEPENDS = "glib-2.0 openssl"
PR = "${INC_PR}.1"

SRC_URI[md5sum] = "119357e1d904be0289e57c80e5ad90ba"
SRC_URI[sha256sum] = "6e37e29b3c3559bac1f2ae0c977f6ceb4d4ce8dc713b691dea8bae57bda92d0b"
