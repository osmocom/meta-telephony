require sofia-sip.inc

PR = "r1"

SRC_URI[md5sum] = "f3582c62080eeecd3fa4cd5d4ccb4225"
SRC_URI[sha256sum] = "2b01bc2e1826e00d1f7f57d29a2854b15fd5fe24695e47a14a735d195dd37c81"
